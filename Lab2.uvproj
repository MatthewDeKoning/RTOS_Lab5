# Keil uVision project Lab2.uvproj, settings and files
target Lab2 (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: ST7735
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c misc: --C99
  c include: ..;..\..\..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: ADC_Collect.c interpreter.c lab2.c os.c PLL.c ST7735.c string.c Switch.c SysTick.c Timer4A.c Timer5A.c UART.c cr4_fft_64_stm32.s osasm.s PID_stm32.s startup.s diskio.c ff.c loader.c heap.c
  group inc
    ../lab 1/ST7735_4C123/: tm4c123gh6pm.h
